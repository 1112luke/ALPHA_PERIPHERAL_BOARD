File: Alpha_Breakout.kicad_pcb (KiCad board)
At the start: 4 copper layers, 66.7 x 74.4 mm, 161 parts, among them IC1 LM66200DRLR, J1 USB_C_Receptacle_USB2.0_14P, J10 Conn_01x03, J11 Conn_01x03, J12 Conn_01x03, J14 Conn_01x03, J15 Conn_01x03, J16 Conn_01x03, J18 Conn_01x02, J19 Conn_01x02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

Commit message: Finished draft of MOST signal routing, except for Pyro/noids channels
Parts:
- moved R20 0.40 mm to (136.1, 120.7)
Routing:
- net /RS-485/DIR_RS485: track 1.27 -> 66.3 mm, vias 0 -> 4
- net USB_V+: track 0.00 -> 43.9 mm, vias 0 -> 4
- net SDA_5V: track 13.9 -> 48.5 mm, vias 0 -> 2
- net Net-(D3-K): track 0.00 -> 21.3 mm
- net PYRO_PWR: track 0.00 -> 8.23 mm
- net /ADCs/SCL: track 3.51 -> 11.3 mm
- net Net-(U4-VDD): track 0.00 -> 6.86 mm
- net Net-(U1-BOOT0): track 0.00 -> 4.39 mm, vias 0 -> 2
- net Net-(D3-A): track 0.00 -> 3.59 mm, vias 0 -> 2
- net Net-(PS1-FB): track 0.71 -> 4.10 mm, vias 1 -> 2
- net Net-(D4-A): track 0.00 -> 2.91 mm
- net Net-(D9-K): track 0.00 -> 1.78 mm, vias 0 -> 1
- net +5V: track 185.1 -> 184.1 mm
- net /stm32f1/SPI1_MOSI: track 50.3 -> 51.2 mm

Commit message: parts⚙️
Parts:
- removed J1: USB_C_Receptacle_USB2.0_14P, Connector_USB:USB_C_Receptacle_JAE_DX07S016JA1R1500
- added J2: USB_C_Receptacle_USB2.0_16P, Connector_USB:USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal, F.Cu at (162.4, 133.0)
- D1, D2: value LED -> White
- D10: value Yellow -> White
- D4: value GREEN -> White
- L1: footprint Inductor_SMD:L_1008_2520Metric -> CYA0630-1.5UH:IND_CYA0630_SHH
- L2: footprint Inductor_SMD:L_1008_2520Metric -> Inductor_SMD:L_Changjiang_FNR4030S
- R20, R21: value 200 -> 100
- moved L1 11.4 mm to (129.7, 121.1), turned to 0 degrees
- moved C40 10.8 mm to (138.2, 125.8), turned to 0 degrees
- moved C35 9.65 mm to (138.2, 128.1)
- moved C34 7.38 mm to (138.2, 130.4)
- moved C39 5.74 mm to (128.9, 126.4)
- moved R18 5.05 mm to (166.3, 122.5), turned to 180 degrees
- moved R4 3.98 mm to (164.1, 127.3)
- moved TP4 3.92 mm to (134.9, 124.0)
- moved C37 3.11 mm to (133.6, 126.3)
- moved IC1 2.79 mm to (136.6, 120.7)
- moved R15 1.48 mm to (138.8, 124.1), turned to 180 degrees
- moved D1 1.40 mm to (164.9, 118.9), turned to 180 degrees
- moved R5 1.39 mm to (160.8, 127.3)
- moved C38 1.25 mm to (172.4, 122.7)
- moved C41 1.21 mm to (167.0, 125.3)
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Routing:
- net Net-(J18-Pin_1): track 35.0 -> 78.9 mm, vias 1 -> 5
- net SDA_5V: track 48.5 -> 13.6 mm, vias 2 -> 0
- net /ADS1231/LC_DRDY/DOUT: track 22.4 -> 57.2 mm, vias 2 -> 4
- net /Solenoids/S4: track 41.1 -> 8.94 mm
- net /Breakout/PB5: track 0.00 -> 32.1 mm
- net /Hardware_Safe/K1: track 31.0 -> 2.95 mm
- net BATT_V+: track 0.00 -> 20.1 mm, vias 0 -> 2
- net PYRO_PWR: track 8.23 -> 28.0 mm
- net Net-(J2-CC2): track 12.8 -> 0.00 mm
- net Net-(C31-Pad2): track 8.88 -> 19.4 mm, vias 0 -> 2
- net (no net): track 8.72 -> 0.07 mm, vias 2 -> 0
- net unconnected-(J2-SBU2-PadB8): track 0.00 -> 8.23 mm
- net USB_V+: track 43.9 -> 35.8 mm, vias 4 -> 2
- net Net-(C31-Pad1): track 24.8 -> 17.0 mm
- net +BATT: track 0.00 -> 6.99 mm
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
Commit message: work
Parts:
- moved R20 3.46 mm to (138.5, 118.2), turned to 0 degrees
- moved D3 0.31 mm to (135.5, 118.1)
- moved IC1 0.20 mm to (136.6, 120.9)
Routing:
- net Net-(J18-Pin_1): track 78.9 -> 36.9 mm, vias 5 -> 1
- net SDA_5V: track 13.6 -> 48.5 mm, vias 0 -> 2
- net /ADS1231/LC_DRDY/DOUT: track 57.2 -> 22.4 mm, vias 4 -> 2
- net /Solenoids/S4: track 8.94 -> 41.1 mm
- net /Breakout/PB5: track 32.1 -> 0.00 mm
- net /Hardware_Safe/K1: track 2.95 -> 31.0 mm
- net PYRO_PWR: track 28.0 -> 8.23 mm
- net Net-(D3-K): track 21.3 -> 4.56 mm
- net unconnected-(J2-SBU2-PadB8): track 8.23 -> 0.00 mm
- net Net-(D6-A): track 11.3 -> 8.38 mm
- net Net-(D4-A): track 0.00 -> 2.91 mm
- net Net-(J2-CC2): track 0.00 -> 1.54 mm
- net +5V: track 190.9 -> 189.6 mm, vias 2 -> 3
- net USB_V+: track 35.8 -> 34.9 mm
- net +BATT: track 6.99 -> 6.20 mm
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
Commit message: 3.3v Routed
Routing:
- net +3.3V: track 5.94 -> 85.8 mm, vias 0 -> 38
- net /Hardware_Safe/K1: track 31.0 -> 33.8 mm
- net /RS-485/DIR_RS485: track 66.3 -> 67.8 mm
- net Net-(U8-T+): track 16.2 -> 17.3 mm
- net /stm32f1/TC1_CS: track 25.5 -> 24.9 mm

Commit message: ⚡️⚙️🐘😂
Parts:
- moved TP4 0.92 mm to (135.1, 123.1)
- moved TP1 0.89 mm to (152.1, 95.2)
- moved C2 0.85 mm to (147.9, 95.2)
- moved C7 0.73 mm to (142.9, 106.4), turned to 45 degrees
- moved R2 0.54 mm to (148.9, 95.2)
- moved R3 0.49 mm to (144.1, 96.0)
- moved C12 0.28 mm to (143.7, 94.7)
- moved C5 0.11 mm to (142.0, 98.4)
Connections:
- J22 pad 1: +BATT -> GND
- J22 pad 2: GND -> +BATT
- J35 pad 3: /Breakout/PB3 -> /Breakout/PB5
- J35 pad 7: /Breakout/PB5 -> /Breakout/PB3
Routing:
- net SW_PWR: track 23.5 -> 174.6 mm, vias 0 -> 8
- net +3.3V: track 85.8 -> 7.88 mm, vias 38 -> 3
- net +5V: track 189.6 -> 120.5 mm, vias 3 -> 1
- net +BATT: track 6.20 -> 71.9 mm
- net Net-(J34-Pin_2): track 0.00 -> 62.1 mm, vias 0 -> 2
- net Net-(U1-BOOT0): track 4.39 -> 66.3 mm, vias 2 -> 4
- net /Breakout/PB8: track 0.00 -> 49.3 mm, vias 0 -> 2
- net /Breakout/PA13: track 0.00 -> 37.6 mm, vias 0 -> 4
- net PYRO_PWR: track 8.23 -> 45.7 mm, vias 0 -> 4
- net /Breakout/PB9: track 0.00 -> 31.1 mm, vias 0 -> 3
- net /RS-485/DIR_RS485: track 67.8 -> 38.1 mm, vias 4 -> 3
- net BATT_V+: track 20.8 -> 45.6 mm
- net Net-(U1-NRST): track 2.97 -> 23.6 mm, vias 0 -> 2
- net /Breakout/PA15: track 0.00 -> 20.3 mm, vias 0 -> 2
- net Net-(D11-K): track 0.00 -> 19.4 mm
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- added copper zone on In2.Cu, net +5V

Commit message: Routed Ground, except for one pad
Parts:
- moved C15 0.71 mm to (124.5, 96.5)
- moved C17 0.36 mm to (124.4, 98.4)
- moved C13 0.21 mm to (125.5, 94.5)
- moved R8 0.10 mm to (125.4, 98.5)
- moved C11 0.10 mm to (125.4, 96.6)
Connections:
- C16 pad 2: +3.3V -> GND
- C17 pad 2: +3.3V -> GND
- C18 pad 1: +3.3V -> GND
- C19 pad 1: +3.3V -> GND
- C2 pad 1: +3.3V -> GND
- C26 pad 2: +3.3V -> GND
- C27 pad 2: +3.3V -> GND
- C28 pad 1: +3.3V -> GND
- C29 pad 1: +3.3V -> GND
- C3 pad 1: +3.3V -> GND
- C30 pad 1: FB -> GND
- C36 pad 1: +3.3V -> GND
- C41 pad 1: +3.3V -> GND
- C5 pad 1: +3.3V -> GND
- C50 pad 2: +3.3V -> GND
- C6 pad 1: +3.3V -> GND
- C7 pad 1: +3.3V -> GND
- J24 pad 1: +3.3V -> GND
- J24 pad 3: /Accelerometer/ACC_SCL -> GND
- J31 pad 1: +3.3V -> GND
- J33 pad 1: +3.3V -> GND
- J35 pad 2: +3.3V -> GND
- L2 pad 2: +3.3V -> GND
- PS1 pad 8: FB -> GND
- Q3 pad 1: /Solenoids/S3 -> GND
- Q4 pad 1: /Solenoids/S4 -> GND
- R1 pad 1: +3.3V -> GND
- R18 pad 1: +3.3V -> GND
- R2 pad 1: +3.3V -> GND
- R28 pad 1: +3.3V -> GND
- R29 pad 1: +3.3V -> GND
- R30 pad 1: +3.3V -> GND
- SW2 pad 1: +3.3V -> GND
- U1 pad 1: +3.3V -> GND
- U1 pad 11: /stm32f1/TC3_CS -> GND
- U1 pad 12: /RS-485/TX_RS485 -> GND
- U1 pad 13: /RS-485/RX_RS485 -> GND
- U1 pad 15: /stm32f1/SPI1_SCK -> GND
- U1 pad 18: /stm32f1/TC1_CS -> GND
- U1 pad 22: /Accelerometer/ACC_SCL -> GND
- U1 pad 24: +3.3V -> GND
- U1 pad 27: /Solenoids/S3 -> GND
- U1 pad 28: /Solenoids/S4 -> GND
- U1 pad 48: +3.3V -> GND
- U1 pad 9: +3.3V -> GND
- U11 pad 1: /RS-485/RX_RS485 -> GND
- U11 pad 4: /RS-485/TX_RS485 -> GND
- U11 pad 8: +3.3V -> GND
- U12 pad 1: +3.3V -> GND
- U12 pad 14: +3.3V -> GND
- U12 pad 4: +3.3V -> GND
- U13 pad 1: +3.3V -> GND
- U2 pad 5: +3.3V -> GND
- U2 pad 8: +3.3V -> GND
- U5 pad 10: /stm32f1/SPI1_SCK -> GND
- U5 pad 5: +3.3V -> GND
- U5 pad 8: +3.3V -> GND
- U5 pad 9: /stm32f1/TC1_CS -> GND
- U6 pad 10: /stm32f1/SPI1_SCK -> GND
- U6 pad 5: +3.3V -> GND
- U6 pad 8: +3.3V -> GND
- U6 pad 9: /stm32f1/TC3_CS -> GND
- U7 pad 10: /stm32f1/SPI1_SCK -> GND
- U7 pad 8: +3.3V -> GND
- U8 pad 10: /stm32f1/SPI1_SCK -> GND
- U8 pad 5: +3.3V -> GND
- U8 pad 8: +3.3V -> GND
- U9 pad 1: +3.3V -> GND
Routing:
- net GND: track 0.04 -> 476.7 mm, vias 0 -> 178
- net /stm32f1/SPI1_SCK: track 55.4 -> 0.00 mm, vias 2 -> 0
- net /Accelerometer/ACC_SCL: track 48.9 -> 0.00 mm, vias 2 -> 0
- net /Solenoids/S4: track 38.2 -> 0.00 mm, vias 2 -> 0
- net /RS-485/RX_RS485: track 36.7 -> 0.00 mm, vias 2 -> 0
- net /Solenoids/S3: track 31.3 -> 0.00 mm, vias 2 -> 0
- net /RS-485/TX_RS485: track 31.1 -> 0.00 mm, vias 2 -> 0
- net /stm32f1/TC1_CS: track 26.1 -> 0.00 mm, vias 2 -> 0
- net +5V: track 120.5 -> 144.2 mm, vias 1 -> 20
- net FB: track 21.5 -> 0.00 mm, vias 2 -> 0
- net /stm32f1/TC3_CS: track 18.3 -> 0.00 mm, vias 2 -> 0
- net +3.3V: track 7.88 -> 0.00 mm, vias 3 -> 0
- net Net-(U6-T-): track 10.4 -> 15.3 mm
- net Net-(J21-Pin_2): track 46.9 -> 48.4 mm
- net Net-(U8-T-): track 5.50 -> 6.92 mm
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
Commit message: clearance🎣
Parts:
- removed the G*** at (149.8, 111.8)
- moved TP5 37.1 mm to (167.7, 76.0)
- moved C45 0.30 mm to (158.0, 118.3)
- moved C15 0.12 mm to (124.4, 96.6)
Connections:
- C16 pad 2: GND -> +3.3V
- C17 pad 2: GND -> +3.3V
- C18 pad 1: GND -> +3.3V
- C19 pad 1: GND -> +3.3V
- C2 pad 1: GND -> +3.3V
- C26 pad 2: GND -> +3.3V
- C27 pad 2: GND -> +3.3V
- C28 pad 1: GND -> +3.3V
- C29 pad 1: GND -> +3.3V
- C3 pad 1: GND -> +3.3V
- C30 pad 1: GND -> FB
- C36 pad 1: GND -> +3.3V
- C41 pad 1: GND -> +3.3V
- C5 pad 1: GND -> +3.3V
- C50 pad 2: GND -> +3.3V
- C6 pad 1: GND -> +3.3V
- C7 pad 1: GND -> +3.3V
- J24 pad 1: GND -> +3.3V
- J24 pad 3: GND -> /Accelerometer/ACC_SCL
- J31 pad 1: GND -> +3.3V
- J33 pad 1: GND -> +3.3V
- J35 pad 2: GND -> +3.3V
- L2 pad 2: GND -> +3.3V
- PS1 pad 8: GND -> FB
- Q3 pad 1: GND -> /Solenoids/S3
- Q4 pad 1: GND -> /Solenoids/S4
- R1 pad 1: GND -> +3.3V
- R18 pad 1: GND -> +3.3V
- R2 pad 1: GND -> +3.3V
- R28 pad 1: GND -> +3.3V
- R29 pad 1: GND -> +3.3V
- R30 pad 1: GND -> +3.3V
- SW2 pad 1: GND -> +3.3V
- U1 pad 1: GND -> +3.3V
- U1 pad 11: GND -> /stm32f1/TC3_CS
- U1 pad 12: GND -> /RS-485/TX_RS485
- U1 pad 13: GND -> /RS-485/RX_RS485
- U1 pad 15: GND -> /stm32f1/SPI1_SCK
- U1 pad 18: GND -> /stm32f1/TC1_CS
- U1 pad 22: GND -> /Accelerometer/ACC_SCL
- U1 pad 24: GND -> +3.3V
- U1 pad 27: GND -> /Solenoids/S3
- U1 pad 28: GND -> /Solenoids/S4
- U1 pad 48: GND -> +3.3V
- U1 pad 9: GND -> +3.3V
- U11 pad 1: GND -> /RS-485/RX_RS485
- U11 pad 4: GND -> /RS-485/TX_RS485
- U11 pad 8: GND -> +3.3V
- U12 pad 1: GND -> +3.3V
- U12 pad 14: GND -> +3.3V
- U12 pad 4: GND -> +3.3V
- U13 pad 1: GND -> +3.3V
- U2 pad 5: GND -> +3.3V
- U2 pad 8: GND -> +3.3V
- U5 pad 10: GND -> /stm32f1/SPI1_SCK
- U5 pad 5: GND -> +3.3V
- U5 pad 8: GND -> +3.3V
- U5 pad 9: GND -> /stm32f1/TC1_CS
- U6 pad 10: GND -> /stm32f1/SPI1_SCK
- U6 pad 5: GND -> +3.3V
- U6 pad 8: GND -> +3.3V
- U6 pad 9: GND -> /stm32f1/TC3_CS
- U7 pad 10: GND -> /stm32f1/SPI1_SCK
- U7 pad 8: GND -> +3.3V
- U8 pad 10: GND -> /stm32f1/SPI1_SCK
- U8 pad 5: GND -> +3.3V
- U8 pad 8: GND -> +3.3V
- U9 pad 1: GND -> +3.3V
Routing:
- net GND: track 476.7 -> 112.2 mm, vias 178 -> 163
- net +3.3V: track 0.00 -> 85.2 mm, vias 0 -> 42
- net /stm32f1/SPI1_SCK: track 0.00 -> 55.3 mm, vias 0 -> 2
- net /Accelerometer/ACC_SCL: track 0.00 -> 48.9 mm, vias 0 -> 2
- net /Solenoids/S4: track 0.00 -> 38.4 mm, vias 0 -> 2
- net /RS-485/RX_RS485: track 0.00 -> 36.7 mm, vias 0 -> 2
- net FB: track 0.00 -> 36.0 mm, vias 0 -> 2
- net +5V: track 144.2 -> 178.6 mm, vias 20 -> 21
- net /Solenoids/S3: track 0.00 -> 31.3 mm, vias 0 -> 2
- net /RS-485/TX_RS485: track 0.00 -> 31.1 mm, vias 0 -> 2
- net /stm32f1/TC1_CS: track 0.00 -> 26.5 mm, vias 0 -> 2
- net Net-(D3-K): track 2.51 -> 24.3 mm, vias 0 -> 2
- net /Accelerometer/ACC_SDA: track 52.6 -> 72.7 mm, vias 2 -> 5
- net +BATT: track 72.2 -> 91.5 mm, vias 0 -> 7
- net /stm32f1/TC3_CS: track 0.00 -> 18.3 mm, vias 0 -> 2
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