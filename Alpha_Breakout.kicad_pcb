# Repository 1112luke/ALPHA_PERIPHERAL_BOARD

File README.md:

<h1 align="center">🥵🚀NDXP Alpha Peripheral Board🚀🌡️</h1>

<h4 align="center">This is the repository for the HARDWARE DESIGN ONLY. Software for the board can be found <a href="https://github.com/1112luke/NDXPCOMPUTER">here</a></h4>

## Introduction

This board was developed for NDXP's Alpha engine. Its purpose is to serve as a peripheral board to the [F.E.R.B.](https://github.com/1112luke/NDXPCOMPUTER) flight computer, and will facilitate data collection for the secifics of the Alpha mission. The board is responsible for collecting pressure and temperature data on the engine, as well as accelerometer data and load cell data during ground testing.

## Specifications

The board has capability in data collection, communication, actuation, and failsafe:

### Data Collection
- 12x 0-5v ADC (used for pressure sensing)
- 4x Thermocouple Channels
- 1x I2C accelerometer interface
- 1x Load Cell Interface

### Communication
- 1x RS-485 Channel (for communication with  [F.E.R.B.](https://github.com/1112luke/NDXPCOMPUTER))
- 1x Serial USB Port

### Actuation
- 4x Solenoid Valve Channels
- 1x Pyro Channel

### Failsafe
- 2x Keyed Switches (Pyro, Solenoids)
- 1x Burnwire Ignition Detection
- 1x E-STOP

## Contributors
- Luke Scholler
- Sebastian Brock

## KiCad design Alpha_Breakout.kicad_pcb

Parts:
J31, J33: Conn_01x02; JST_BM02B-GHS-TBT_LF__SN_; JLC# C161690
R23, R25: 20k; R_0402_1005Metric; Mouser Part Number 71-RCA040220K0JNED

Connections:
+3.3V: J31.1, J33.1; also elsewhere on the board
/Hardware_Safe/BW1: J33.2, R25.1; also elsewhere on the board
/Hardware_Safe/K1: J31.2, R23.1; also elsewhere on the board
GND: R23.2, R25.2; also elsewhere on the board

Notes on the sheet:
E-STOP
Burn Wire

Parts:
J23: Conn_01x02; CONN_SM02B-GHS_JST; JLC# C189893
U11: SP3485EN; SOIC-8_3.9x4.9mm_P1.27mm; Mouser Part Number 701-SP3485EN-L/TR; JLC# C8963

Connections:
+3.3V: U11.8 (VCC); also elsewhere on the board
/RS-485/DIR_RS485: U11.2 (~RE), U11.3 (DE); also elsewhere on the board
/RS-485/RX_RS485: U11.1 (RO); also elsewhere on the board
/RS-485/TX_RS485: U11.4 (DI); also elsewhere on the board
GND: U11.5 (GND); also elsewhere on the board
unnamed: J23.1, U11.6 (A)
unnamed: J23.2, U11.7 (B)

Parts:
D5, D6, D7, D8: D; D_SMA; JLC# C8678
J25: Conn_01x02; JST_BM02B-GHS-TBT_LF__SN_; JLC# C161690
J26, J27, J28, J29: Conn_01x02; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal; JLC# C918120
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
Q1, Q2, Q3, Q4: NMOS; SOT23; JLC# C2891732

Connections:
+BATT: J25.1, JP1.1 (A); also elsewhere on the board
/Solenoids/S1: Q1.2 (G); also elsewhere on the board
/Solenoids/S2: Q2.2 (G); also elsewhere on the board
/Solenoids/S3: Q3.2 (G); also elsewhere on the board
/Solenoids/S4: Q4.2 (G); also elsewhere on the board
GND: Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S); also elsewhere on the board
unnamed: D5.2 (A), J26.2, Q1.1 (D)
unnamed: D6.2 (A), J27.2, Q2.1 (D)
unnamed: D7.2 (A), J28.2, Q3.1 (D)
unnamed: D8.2 (A), J29.2, Q4.1 (D)
SW_PWR: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J25.2, J26.1, J27.1, J28.1, J29.1, JP1.2 (B)

Notes on the sheet:
PWR_ENABLE

Parts:
J24: Conn_01x04; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal; JLC# C189895
TP5: TestPoint; TestPoint_Pad_D1.0mm

Connections:
+3.3V: J24.1; also elsewhere on the board
/Accelerometer/ACC_SCL: J24.3; also elsewhere on the board
/Accelerometer/ACC_SDA: J24.2, TP5.1; also elsewhere on the board
GND: J24.4; also elsewhere on the board

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_DIN965_Pad
J35: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical

Connections:
+3.3V: J35.2; also elsewhere on the board
+5V: J35.1; also elsewhere on the board
/Breakout/PA13: J35.6; also elsewhere on the board
/Breakout/PA14: J35.8; also elsewhere on the board
/Breakout/PA15: J35.10; also elsewhere on the board
/Breakout/PB3: J35.7; also elsewhere on the board
/Breakout/PB4: J35.5; also elsewhere on the board
/Breakout/PB5: J35.3; also elsewhere on the board
/Breakout/PB8: J35.9; also elsewhere on the board
/Breakout/PB9: J35.4; also elsewhere on the board
GND: J35.11, J35.12; also elsewhere on the board

Parts:
C10, C11, C12, C13, C16, C17, C18, C19, C20, C21, C22, C23, C26, C27, C28, C29: .01uF; C_0402_1005Metric
C14, C15, C24, C25: 0.1uF; C_0402_1005Metric
J18, J19, J20, J21: Conn_01x02; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal; JLC# C918120
R6, R7, R8, R9, R10, R11, R12, R13: 100Ω; R_0402_1005Metric
U5, U6, U7, U8: MAX31856; TSSOP-14_4.4x5mm_P0.65mm; JLC# C2653162

Connections:
+3.3V: C16.2, C17.2, C18.1, C19.1, C26.2, C27.2, C28.1, C29.1, U5.5 (AVDD), U5.8 (DVDD), U6.5 (AVDD), U6.8 (DVDD), U7.5 (AVDD), U7.8 (DVDD), U8.5 (AVDD), U8.8 (DVDD); also elsewhere on the board
/stm32f1/SPI1_MISO: U5.11 (SDO), U6.11 (SDO), U7.11 (SDO), U8.11 (SDO); also elsewhere on the board
/stm32f1/SPI1_MOSI: U5.12 (SDI), U6.12 (SDI), U7.12 (SDI), U8.12 (SDI); also elsewhere on the board
/stm32f1/SPI1_SCK: U5.10 (SCK), U6.10 (SCK), U7.10 (SCK), U8.10 (SCK); also elsewhere on the board
/stm32f1/TC1_CS: U5.9 (~CS); also elsewhere on the board
/stm32f1/TC2_CS: U8.9 (~CS); also elsewhere on the board
/stm32f1/TC3_CS: U6.9 (~CS); also elsewhere on the board
/stm32f1/TC4_CS: U7.9 (~CS); also elsewhere on the board
GND: C10.1, C11.1, C12.1, C13.1, C16.1, C17.1, C18.2, C19.2, C20.1, C21.1, C22.1, C23.1, C26.1, C27.1, C28.2, C29.2, U5.1 (AGND), U5.14 (DGND), U6.1 (AGND), U6.14 (DGND), U7.1 (AGND), U7.14 (DGND), U8.1 (AGND), U8.14 (DGND); also elsewhere on the board
unnamed: J18.1, R7.1, U5.2 (BIAS)
unnamed: J18.2, R6.1
unnamed: J19.1, R9.1, U6.2 (BIAS)
unnamed: J19.2, R8.1
unnamed: J20.1, R11.1, U7.2 (BIAS)
unnamed: J20.2, R10.1
unnamed: J21.1, R13.1, U8.2 (BIAS)
unnamed: J21.2, R12.1
unnamed: C10.2, C14.1, R6.2, U5.4 (T+)
unnamed: C12.2, C14.2, R7.2, U5.3 (T-)
unnamed: C11.2, C15.1, R8.2, U6.4 (T+)
unnamed: C13.2, C15.2, R9.2, U6.3 (T-)
unnamed: C20.2, C24.1, R10.2, U7.4 (T+)
unnamed: C22.2, C24.2, R11.2, U7.3 (T-)
unnamed: C21.2, C25.1, R12.2, U8.4 (T+)
unnamed: C23.2, C25.2, R13.2, U8.3 (T-)

Parts:
C48: 0.1uF; C_0402_1005Metric; Mouser Part Number 581-0402YD104JAT2A
C49, C50: 1uf; C_0402_1005Metric; Mouser Part Number 581-04023D105KAT2A
J30: Conn_01x04; JST_SM04B-GHS-TB_LF__SN_-; JLC# C189895
U12: ADS1231ID; SOIC127P600X175-16N; Mouser Part Number 595-ADS1231ID; JLC# C486034

Connections:
+3.3V: C50.2, U12.1 (DVDD), U12.4 (SPEED), U12.14 (~PDWN); also elsewhere on the board
+5V: C49.1, J30.4, U12.10 (VREFP), U12.13 (AVDD); also elsewhere on the board
/ADS1231/LC_DRDY/DOUT: U12.16 (~DRDY/DOUT); also elsewhere on the board
/ADS1231/LC_SCLK: U12.15 (SCLK); also elsewhere on the board
GND: C49.2, C50.1, J30.1, U12.2 (GND), U12.3 (CLKIN), U12.9 (VREFN), U12.11 (SGND), U12.12 (PSW); also elsewhere on the board
unnamed: C48.1, U12.6 (CAP)
unnamed: C48.2, U12.5 (CAP)
unnamed: J30.2, U12.7 (AINP)
unnamed: J30.3, U12.8 (AINN)

Parts:
J34: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J36: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; JLC# C158012
JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
Q5: SSM3J328R; SOT95P240X88-3N; JLC# C396016
Q6: L2N7002SLLT1G; SOT-23; JLC# C22446827
R26: 100k; R_0603_1608Metric
R27: 200k; R_0603_1608Metric
TP6: TestPoint; TestPoint_Pad_D1.0mm

Connections:
+BATT: J36.1, JP2.1 (A); also elsewhere on the board
/Pyro/PYRO1: Q6.2 (G); also elsewhere on the board
GND: J34.1, Q6.3 (S); also elsewhere on the board
unnamed: J34.2, Q5.1 (D)
unnamed: Q5.2 (G), R26.2, R27.1, TP6.1
unnamed: Q6.1 (D), R27.2
PYRO_PWR: J36.2, JP2.2 (B), Q5.3 (S), R26.1

Notes on the sheet:
PYRO KEY
SSM3J328R PMOS
battery at 12v, gate at 4v
Found this pmos by digikey, 20v, in stock, pmos, scrolling for high amperage

Schematic: stm32f1.kicad_sch

Parts:
C1, C2, C3, C4, C6: 100nF; C_0402_1005Metric
C5: 10uF; C_0805_2012Metric
C7: 1uF; C_0603_1608Metric
D9: Red; LED_0603_1608Metric; JLC# C19171390
D10: White; LED_0603_1608Metric; JLC# C19273150
D11: Blue; LED_0603_1608Metric; JLC# C19171394
R1, R2: 4.7K; R_0402_1005Metric
R3: 10k; R_0603_1608Metric
R28, R29, R30: 100Ω; R_0402_1005Metric
SW1, SW2: SW_Push; SW_SPST_B3U-1000P; JLC# C231329
U1: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm; JLC# C8734

Connections:
+3.3V: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, R1.1, R2.1, R28.1, R29.1, R30.1, SW2.1, U1.1 (VBAT), U1.9 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD); also elsewhere on the board
/ADCs/SCL: R1.2, U1.42 (PB6); also elsewhere on the board
/ADCs/SDA: R2.2, U1.43 (PB7); also elsewhere on the board
/ADS1231/LC_DRDY/DOUT: U1.32 (PA11); also elsewhere on the board
/ADS1231/LC_SCLK: U1.33 (PA12); also elsewhere on the board
/Accelerometer/ACC_SCL: U1.22 (PB11); also elsewhere on the board
/Accelerometer/ACC_SDA: U1.21 (PB10); also elsewhere on the board
/Breakout/PA13: U1.34 (PA13); also elsewhere on the board
/Breakout/PA14: U1.37 (PA14); also elsewhere on the board
/Breakout/PA15: U1.38 (PA15); also elsewhere on the board
/Breakout/PB3: U1.39 (PB3); also elsewhere on the board
/Breakout/PB4: U1.40 (PB4); also elsewhere on the board
/Breakout/PB5: U1.41 (PB5); also elsewhere on the board
/Breakout/PB8: U1.45 (PB8); also elsewhere on the board
/Breakout/PB9: U1.46 (PB9); also elsewhere on the board
/Hardware_Safe/BW1: U1.20 (PB2); also elsewhere on the board
/Hardware_Safe/K1: U1.5 (PD0); also elsewhere on the board
/Pyro/PYRO1: U1.29 (PA8); also elsewhere on the board
/RS-485/DIR_RS485: U1.14 (PA4); also elsewhere on the board
/RS-485/RX_RS485: U1.13 (PA3); also elsewhere on the board
/RS-485/TX_RS485: U1.12 (PA2); also elsewhere on the board
/Solenoids/S1: U1.25 (PB12); also elsewhere on the board
/Solenoids/S2: U1.26 (PB13); also elsewhere on the board
/Solenoids/S3: U1.27 (PB14); also elsewhere on the board
/Solenoids/S4: U1.28 (PB15); also elsewhere on the board
/prog/USB_RX: U1.30 (PA9); also elsewhere on the board
/prog/USB_TX: U1.31 (PA10); also elsewhere on the board
/stm32f1/SPI1_MISO: U1.16 (PA6); also elsewhere on the board
/stm32f1/SPI1_MOSI: U1.17 (PA7); also elsewhere on the board
/stm32f1/SPI1_SCK: U1.15 (PA5); also elsewhere on the board
/stm32f1/TC1_CS: U1.18 (PB0); also elsewhere on the board
/stm32f1/TC2_CS: U1.19 (PB1); also elsewhere on the board
/stm32f1/TC3_CS: U1.11 (PA1); also elsewhere on the board
/stm32f1/TC4_CS: U1.10 (PA0); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, R3.2, SW1.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS); also elsewhere on the board
unnamed: D9.2 (A), R28.2
unnamed: D9.1 (K), U1.2 (PC13)
unnamed: D10.2 (A), R29.2
unnamed: D10.1 (K), U1.3 (PC14)
unnamed: D11.2 (A), R30.2
unnamed: D11.1 (K), U1.4 (PC15)
unnamed: R3.1, SW2.2, U1.44 (BOOT0)
unnamed: C1.1, SW1.2, U1.7 (NRST)

Notes on the sheet:
I2C Pullup
for VDD Pins
for vdda

Schematic: ADCs.kicad_sch

Parts:
C8, C9: 1uF; C_0603_1608Metric
J3, J4, J5, J7, J8, J9, J10, J11, J12, J14, J15, J16: Conn_01x03; TerminalBlock_Phoenix_MPT-0,5-3-2.54_1x03_P2.54mm_Horizontal; JLC# C918121
R22, R33: 4.7K; R_0402_1005Metric
R31, R32: 5Ω; R_0402_1005Metric
U3, U4: ADS7828; TSSOP-16_4.4x5mm_P0.65mm; JLC# C701649
U13: TCA9517ADGK; VSSOP-8_3x3mm_P0.65mm; JLC# C201698

Connections:
+3.3V: U13.1 (VCCA); also elsewhere on the board
+5V: J3.1, J4.1, J5.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J14.1, J15.1, J16.1, R22.1, R31.1, R32.1, R33.1, U3.10 (REF), U4.10 (REF), U4.12 (A0), U13.8 (VCCB); also elsewhere on the board
/ADCs/SCL: U13.2 (SCLA); also elsewhere on the board
/ADCs/SDA: U13.3 (SDAA); also elsewhere on the board
CH_02: J10.2, U3.3 (CH2)
CH_03: J14.2, U3.4 (CH3)
CH_04: J3.2, U3.5 (CH4)
CH_05: J7.2, U3.6 (CH5)
CH_06: J11.2, U3.7 (CH6)
CH_07: J15.2, U3.8 (CH7)
CH_08: J4.2, U4.1 (CH0)
CH_09: J8.2, U4.2 (CH1)
CH_10: J12.2, U4.3 (CH2)
CH_11: J16.2, U4.4 (CH3)
CH_12: J5.2, U4.5 (CH4)
CH_13: J9.2, U4.6 (CH5)
GND: C8.2, C9.2, J3.3, J4.3, J5.3, J7.3, J8.3, J9.3, J10.3, J11.3, J12.3, J14.3, J15.3, J16.3, U3.9 (GND), U3.11 (COM), U3.12 (A0), U3.13 (A1), U4.9 (GND), U4.11 (COM), U4.13 (A1), U13.4 (GND); also elsewhere on the board
unnamed: C8.1, R31.2, U3.16 (VDD)
unnamed: C9.1, R32.2, U4.16 (VDD)
SCL_5V: R22.2, U3.14 (SCL), U4.14 (SCL), U13.7 (SCLB)
SDA_5V: R33.2, U3.15 (SDA), U4.15 (SDA), U13.6 (SDAB)

Notes on the sheet:
Terminal Blocks
Analog -> Digital
Level Shifter
internal pullup to VCCB

Schematic: Power.kicad_sch

Parts:
C30: 470pF; C_0402_1005Metric
C31, C38: 100nF; C_0402_1005Metric
C32: 10uF; C_0805_2012Metric
C33: 2.2uF; C_0603_1608Metric
C34, C37, C40: 22uF; C_1206_3216Metric; JLC# C12891
C35, C36, C39, C41, C42, C44: 22uF; C_1206_3216Metric
C43: 100nF; C_0402_1005Metric; JLC# C60474
C45: 1uF; C_0402_1005Metric; JLC# C29266
C46: 2.2uF; C_0402_1005Metric
C47: 10nF; C_0402_1005Metric
D1, D2, D4: White; LED_0603_1608Metric; JLC# C19273150
D3: BLUE; LED_0603_1608Metric; JLC# C19171394
IC1: LM66200DRLR; SOT8; JLC# C3235556
J22: Conn_01x02; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal; JLC# C431092
L1: 1.5uH; IND_CYA0630_SHH; JLC# C5189745
L2: 4.7uH; L_Changjiang_FNR4030S; JLC# C167874
PS1: TPS513885VABR; CONV_TPS513885VABR; PARTREV B; JLC# C41935536
R14: 1k; R_0402_1005Metric
R15, R17: 0Ω; R_0402_1005Metric
R16: 100k; R_0603_1608Metric
R18, R20, R21: 100Ω; R_0402_1005Metric
R19: 200Ω; R_0402_1005Metric
TP4: TestPoint; TestPoint_Pad_D1.0mm
U9: AP63203WU; TSOT-23-6; JLC# C780769
U10: LP2985-3.3; SOT-23-5; JLC# C95414

Connections:
+3.3V: C36.1, C41.1, L2.2, R18.1, U9.1 (FB); also elsewhere on the board
+5V: C32.1, IC1.2 (VOUT@1), IC1.7 (VOUT@2), R20.1, TP4.1, U9.2 (EN), U9.3 (IN); also elsewhere on the board
+BATT: C34.1, C37.1, C40.1, C43.1, C45.1, J22.2, PS1.1 (VIN), U10.1 (VIN), U10.3 (ON/~OFF); also elsewhere on the board
BATT_V+: C35.1, C39.1, C42.1, C44.1, IC1.3 (VIN1), L1.2, R17.1, R19.1
FB: C30.1, PS1.8 (VOUT), R17.2
GND: C32.2, C33.1, C34.2, C35.2, C36.2, C37.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, D1.1 (K), D2.1 (K), D4.1 (K), IC1.1 (GND@1), IC1.4 (ON), IC1.5 (GND@2), J22.1, PS1.3 (PGND), PS1.11 (PGND), U9.4 (GND), U10.2 (GND); also elsewhere on the board
unnamed: C30.2, R14.1
unnamed: C31.1, R15.1
unnamed: C31.2, L1.1, PS1.2 (SW), PS1.12 (SW)
unnamed: D1.2 (A), R18.2
unnamed: D2.2 (A), R19.2
unnamed: D3.2 (A), R20.2
unnamed: D3.1 (K), IC1.8 (ST), R21.1
unnamed: D4.2 (A), R21.2
unnamed: PS1.7 (FB), R14.2
unnamed: PS1.4 (PG), R16.1
unnamed: PS1.13 (VBST), R15.2
unnamed: C33.2, PS1.10 (VCC), R16.2
unnamed: C38.2, U9.6 (BST)
unnamed: C38.1, L2.1, U9.5 (SW)
unnamed: C47.1, U10.4 (BP)
USB_V+: IC1.6 (VIN2); also elsewhere on the board
en: C46.1, PS1.5 (MODE), PS1.6 (EN), U10.5 (VOUT)

Notes on the sheet:
Battery
TODO: ensure all parts here are rated for voltage/amperage
Dual Diode
3.3v Switching Regulator
5v Switching Regulator
Enable Reg (3.3v)

Schematic: prog.kicad_sch

Parts:
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; JLC# C2765186
R4, R5: 5.1k; R_0402_1005Metric
TP1: TestPoint; TestPoint_Pad_D1.0mm
U2: CH340N; JEITA_SOIC-8_3.9x4.9mm_P1.27mm; JLC# C2977777

Connections:
+3.3V: U2.5 (VCC), U2.8 (V3); also elsewhere on the board
/prog/USB_RX: U2.7 (RXD); also elsewhere on the board
/prog/USB_TX: TP1.1, U2.6 (TXD); also elsewhere on the board
GND: J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), R4.2, R5.2, U2.3 (GND); also elsewhere on the board
unnamed: J2.A5 (CC1), R5.1
unnamed: J2.B5 (CC2), R4.1
unnamed: J2.A6 (D+), J2.B6 (D+), U2.1 (UD+)
unnamed: J2.A7 (D-), J2.B7 (D-), U2.2 (UD-)
USB_V+: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS); also elsewhere on the board

Board: 4 copper layers, 66.7 x 74.4 mm, 159 parts (0 on the bottom side), 115 nets.

## Commit log

2025-10-05 initial ⚡️
2025-10-05 adcs
2025-10-05 added luke name
2025-10-05 Textbox Test
2025-10-05 fixed
2025-10-05 Added Thermocouple Amp sheet
2025-10-05 power
2025-10-05 Completed schematic for one IC
2025-10-06 reg🟡
2025-10-06 layout🏄‍♂️
2025-10-06 test
2025-10-06 Added thermocouple footprints
    8205 used in case we end up hand soldering this thing
2025-10-06 Routed ThermoAmps to STM32
2025-10-06 thermo🌡️
2025-10-06 Fixed Filters on ADCs
2025-10-06 fixed power
2025-10-06 added 2 pin connector files for rs232
2025-10-07 plug🔌
2025-10-08 Added Solenoids (Double Check Diode Type?)
2025-10-08 oops I forgot to specify resistor footprint
2025-10-08 Revmoed Diodes (Built in to MOSFET)
2025-10-08 Put Diodes Back
2025-10-08 Removed extraneous Resistors
2025-10-08 Added Power Status LEDs
2025-10-09 Not Entirely Sure
2025-10-09 Connected solenoids, some error fixes
2025-10-09 read description
2025-10-09 arranged board
2025-10-09 estop added
2025-10-10 Added Load Cell IC and Circuitry, fixed wacked out symbol
2025-10-12 Load Cell
2025-10-12 added leds🔴🟡🔵
2025-10-12 Breakout
2025-10-13 lots🅿️
2025-10-13 bunchostuff💐
2025-10-13 Added Golden Dome yay
2025-10-13 done ✅
2025-10-13 fixed??
2025-10-13 settings ⚙️
2025-10-14 Moved Mary to avoid MCU
2025-10-15 ROuted 5V Power
2025-10-15 routed initial🛣️
2025-10-15 3.3 partially routed, to avoid signal
2025-10-16 signal
2025-10-16 newest
2025-10-16 Routed some stuff
2025-10-16 More Routing
2025-10-16 routs
2025-10-16 First Draft of BOM
    Didn't select some compoentns like diodes that I don't fully understand. Also, some components have multiple variants so we must be careful.
2025-10-16 Finished draft of MOST signal routing, except for Pyro/noids channels
2025-10-16 parts⚙️
2025-10-16 work
2025-10-16 3.3v Routed
2025-10-17 Routed Ground, except for one pad
2025-10-27 clearance🎣
2025-10-27 fixed warnings⚠️
2025-10-27 Initial pass at finding Mouser part numbers
2025-10-28 touchups 💅
2025-10-28 fixed usb 🔌
2025-10-28 added version 🚅
2025-10-28 changed noid fets🎚️
2025-10-29 v1.0 DONE6️⃣7️⃣🚀⚡️🔋
2025-10-29 bomupdate
2025-11-05 edges
2025-11-06 done
2025-11-06 productio ⚙️
